options:
  parameters:
    generate_options: qt_gui
    id: qpsk_5g
    output_language: python
    title: QPSK - 5G
  states: {}

blocks:
- name: K
  id: variable
  parameters:
    value: '512'
  states: {}
- name: N
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: PC_dec
  id: variable_polar_decoder_sc_def
  parameters:
    block_size: N
    frozen_bit_positions: frozen_pos
    frozen_bit_values: frozen_val
    ndim: '0'
    num_info_bits: K
  states: {}
- name: PC_enc
  id: variable_polar_encoder_def
  parameters:
    block_size: N
    frozen_bit_positions: frozen_pos
    frozen_bit_values: frozen_val
    is_packed: 'False'
    ndim: '0'
    num_info_bits: K
  states: {}
- name: RelSeq
  id: variable
  parameters:
    value: np.array([0, 1, 2, 4, 8, 16, 32, 3, 5, 64, 9, 6, 17, 10, 18, 128, 12, 33, 65, 20, 256, 34, 24, 36, 7, 129, 66, 512, 11, 40, 68, 130, 19, 13, 48, 14, 72, 257, 21, 132, 35, 258, 26, 513, 80, 37, 25, 22, 136, 260, 264, 38, 514, 96, 67, 41, 144, 28, 69, 42, 516, 49, 74, 272, 160, 520, 288, 528, 192, 544, 70, 44, 131, 81, 50, 73, 15, 320, 133, 52, 23, 134, 384, 76, 137, 82, 56, 27, 97, 39, 259, 84, 138, 145, 261, 29, 43, 98, 515, 88, 140, 30, 146, 71, 262, 265, 161, 576, 45, 100, 640, 51, 148, 46, 75, 266, 273, 517, 104, 162, 53, 193, 152, 77, 164, 768, 268, 274, 518, 54, 83, 57, 521, 112, 135, 78, 289, 194, 85, 276, 522, 58, 168, 139, 99, 86, 60, 280, 89, 290, 529, 524, 196, 141, 101, 147, 176, 142, 530, 321, 31, 200, 90, 545, 292, 322, 532, 263, 149, 102, 105, 304, 296, 163, 92, 47, 267, 385, 546, 324, 208, 386, 150, 153, 165, 106, 55, 328, 536, 577, 548, 113, 154, 79, 269, 108, 578, 224, 166, 519, 552, 195, 270, 641, 523, 275, 580, 291, 59, 169, 560, 114, 277, 156, 87, 197, 116, 170, 61, 531, 525, 642, 281, 278, 526, 177, 293, 388, 91, 584, 769, 198, 172, 120, 201, 336, 62, 282, 143, 103, 178, 294, 93, 644, 202, 592, 323, 392, 297, 770, 107, 180, 151, 209, 284, 648, 94, 204, 298, 400, 608, 352, 325, 533, 155, 210, 305, 547, 300, 109, 184, 534, 537, 115, 167, 225, 326, 306, 772, 157, 656, 329, 110, 117, 212, 171, 776, 330, 226, 549, 538, 387, 308, 216, 416, 271, 279, 158, 337, 550, 672, 118, 332, 579, 540, 389, 173, 121, 553, 199, 784, 179, 228, 338, 312, 704, 390, 174, 554, 581, 393, 283, 122, 448, 353, 561, 203, 63, 340, 394, 527, 582, 556, 181, 295, 285, 232, 124, 205, 182, 643, 562, 286, 585, 299, 354, 211, 401, 185, 396, 344, 586, 645, 593, 535, 240, 206, 95, 327, 564, 800, 402, 356, 307, 301, 417, 213, 568, 832, 588, 186, 646, 404, 227, 896, 594, 418, 302, 649, 771, 360, 539, 111, 331, 214, 309, 188, 449, 217, 408, 609, 596, 551, 650, 229, 159, 420, 310, 541, 773, 610, 657, 333, 119, 600, 339, 218, 368, 652, 230, 391, 313, 450, 542, 334, 233, 555, 774, 175, 123, 658, 612, 341, 777, 220, 314, 424, 395, 673, 583, 355, 287, 183, 234, 125, 557, 660, 616, 342, 316, 241, 778, 563, 345, 452, 397, 403, 207, 674, 558, 785, 432, 357, 187, 236, 664, 624, 587, 780, 705, 126, 242, 565, 398, 346, 456, 358, 405, 303, 569, 244, 595, 189, 566, 676, 361, 706, 589, 215, 786, 647, 348, 419, 406, 464, 680, 801, 362, 590, 409, 570, 788, 597, 572, 219, 311, 708, 598, 601, 651, 421, 792, 802, 611, 602, 410, 231, 688, 653, 248, 369, 190, 364, 654, 659, 335, 480, 315, 221, 370, 613, 422, 425, 451, 614, 543, 235, 412, 343, 372, 775, 317, 222, 426, 453, 237, 559, 833, 804, 712, 834, 661, 808, 779, 617, 604, 433, 720, 816, 836, 347, 897, 243, 662, 454, 318, 675, 618, 898, 781, 376, 428, 665, 736, 567, 840, 625, 238, 359, 457, 399, 787, 591, 678, 434, 677, 349, 245, 458, 666, 620, 363, 127, 191, 782, 407, 436, 626, 571, 465, 681, 246, 707, 350, 599, 668, 790, 460, 249, 682, 573, 411, 803, 789, 709, 365, 440, 628, 689, 374, 423, 466, 793, 250, 371, 481, 574, 413, 603, 366, 468, 655, 900, 805, 615, 684, 710, 429, 794, 252, 373, 605, 848, 690, 713, 632, 482, 806, 427, 904, 414, 223, 663, 692, 835, 619, 472, 455, 796, 809, 714, 721, 837, 716, 864, 810, 606, 912, 722, 696, 377, 435, 817, 319, 621, 812, 484, 430, 838, 667, 488, 239, 378, 459, 622, 627, 437, 380, 818, 461, 496, 669, 679, 724, 841, 629, 351, 467, 438, 737, 251, 462, 442, 441, 469, 247, 683, 842, 738, 899, 670, 783, 849, 820, 728, 928, 791, 367, 901, 630, 685, 844, 633, 711, 253, 691, 824, 902, 686, 740, 850, 375, 444, 470, 483, 415, 485, 905, 795, 473, 634, 744, 852, 960, 865, 693, 797, 906, 715, 807, 474, 636, 694, 254, 717, 575, 913, 798, 811, 379, 697, 431, 607, 489, 866, 723, 486, 908, 718, 813, 476, 856, 839, 725, 698, 914, 752, 868, 819, 814, 439, 929, 490, 623, 671, 739, 916, 463, 843, 381, 497, 930, 821, 726, 961, 872, 492, 631, 729, 700, 443, 741, 845, 920, 382, 822, 851, 730, 498, 880, 742, 445, 471, 635, 932, 687, 903, 825, 500, 846, 745, 826, 732, 446, 962, 936, 475, 853, 867, 637, 907, 487, 695, 746, 828, 753, 854, 857, 504, 799, 255, 964, 909, 719, 477, 915, 638, 748, 944, 869, 491, 699, 754, 858, 478, 968, 383, 910, 815, 976, 870, 917, 727, 493, 873, 701, 931, 756, 860, 499, 731, 823, 922, 874, 918, 502, 933, 743, 760, 881, 494, 702, 921, 501, 876, 847, 992, 447, 733, 827, 934, 882, 937, 963, 747, 505, 855, 924, 734, 829, 965, 938, 884, 506, 749, 945, 966, 755, 859, 940, 830, 911, 871, 639, 888, 479, 946, 750, 969, 508, 861, 757, 970, 919, 875, 862, 758, 948, 977, 923, 972, 761, 877, 952, 495, 703, 935, 978, 883, 762, 503, 925, 878, 735, 993, 885, 939, 994, 980, 926, 764, 941, 967, 886, 831, 947, 507, 889, 984, 751, 942, 996, 971, 890, 509, 949, 973, 1000, 892, 950, 863, 759, 1008, 510, 979, 953, 763, 974, 954, 879, 981, 982, 927, 995, 765, 956, 887, 985, 997, 986, 943, 891, 998, 766, 511, 988, 1001, 951, 1002, 893, 975, 894, 1009, 955, 1004, 1010, 957, 983, 958, 987, 1012, 999, 1016, 767, 989, 1003, 990, 1005, 959, 1011, 1013, 895, 1006, 1014, 1017, 1018, 991, 1020, 1007, 1015, 1019, 1021, 1022, 1023])
  states: {}
- name: access_code
  id: variable
  parameters:
    value: '"11100001010110101110100010010011"'
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: bit_rate / 1
  states: {}
- name: bit_rate
  id: variable
  parameters:
    value: 800e3
  states: {}
- name: epsilon
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    start: '0.99'
    step: '0.0001'
    stop: '1.01'
    value: '1.0'
    widget: eng_slider
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    start: '-0.002'
    step: '0.00001'
    stop: '0.002'
    value: '0.0'
    widget: eng_slider
  states: {}
- name: frozen_pos
  id: variable
  parameters:
    value: np.sort(RelSeq[RelSeq < N][:N-K])
  states: {}
- name: frozen_val
  id: variable
  parameters:
    value: np.zeros(N-K, dtype=int)
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    start: '0.0'
    step: '0.01'
    stop: '10.0'
    value: '0'
    widget: eng_slider
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: '1'
  states: {}
- name: qpsk
  id: variable_constellation
  parameters:
    const_points: '[0.0, 1.0]'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    sym_map: '[0, 1]'
    type: qpsk
  states: {}
- name: rrc_filter_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.25'
    gain: sps
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: baud_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud_rate * sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '3'
  states: {}
- name: sync_len
  id: variable
  parameters:
    value: '32'
  states: {}
- name: taps
  id: variable
  parameters:
    value: np.array(rrc_filter_taps)
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: 1e3
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '256'
    minimum: '0'
    seed: '42'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: transmitido_hat.txt
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: transmitido.txt
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: alice.txt
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      constellation_qpsk() tem |z| = 2;
      o Costas espera amplitude unitaria
    const: '0.5'
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (32, N)
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"quadro"'
    packet_len: K-32
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: bit_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0xE1, 0x5A, 0xE8, 0x93)
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: epsilon
    freq_offset: freq_offset
    noise_voltage: noise_voltage
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: qpsk
    npwr: '-1'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 2*np.pi/200
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"quadro"'
    packed: 'False'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"quadro"'
    packed: 'False'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '8'
  states: {state: disabled}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '0.01'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          """
          Monitor de BLER — conta quadros que chegam ao CRC (porta 0) e quadros
          que passam no CRC (porta 1), e imprime a BLER periodicamente.
          """

          def __init__(self, tag_name="quadro", freq_att=20):
              gr.basic_block.__init__(
                  self, name='BLER Monitor',
                  in_sig=[np.uint8, np.uint8],
                  out_sig=[],
              )
              self.tag_key = pmt.intern(tag_name)
              self.quadros = 0
              self.quadros_validos = 0
              self.q_tot = 0
              self.qv_tot = 0
              self.freq_att = freq_att

          def forecast(self, noutput_items, ninputs):
              return [0, 0]

          def general_work(self, input_items, output_items):
              for port, counter_name in ((0, 'quadros'), (1, 'quadros_validos')):
                  n = len(input_items[port])
                  if n:
                      tags = self.get_tags_in_window(port, 0, n, self.tag_key)
                      if counter_name == 'quadros':
                          self.quadros += len(tags)
                      else:
                          self.quadros_validos += len(tags)
                      self.consume(port, n)
              if self.quadros and self.quadros % self.freq_att == 0:
                  bler = 1.0 - self.quadros_validos / self.quadros
                  self.q_tot += self.quadros; self.qv_tot += self.quadros_validos
                  bler_tot = 1.0 - self.qv_tot / self.q_tot
                  print(f"[BLER] quadros={self.quadros}  quadros_validos={self.quadros_validos}  BLER={bler:.4f}")
                  print(f"[BLER TOTAL] quadros={self.q_tot}  quadros_validos={self.qv_tot}  BLER={bler_tot:.4f}")
                  self.quadros = 0; self.quadros_validos = 0
              return 0
    freq_att: '2000'
    tag_name: '''quadro'''
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          """
          Find Access Code — invariante às quatro ambiguidades de fase da QPSK.

          Procura o access code no fluxo de LLRs correlacionando, em paralelo, contra
          as quatro versões do código correspondentes às rotações de 0°, 90°, 180° e
          270° da constelação. Ao encontrar, desfaz a rotação no payload antes de
          repassá-lo adiante, de modo que o Costas Loop pode travar em qualquer uma
          das quatro fases sem quebrar o enquadramento.
          """

          def __init__(self, access_code="", payload_len_in_bits=0, tag_key="", threshold=0.9):
              gr.basic_block.__init__(
                  self,
                  name='Find Access Code',
                  in_sig=[np.float32],
                  out_sig=[np.float32],
              )
              ac = np.array([2 * int(b) - 1 for b in access_code], dtype=np.float32)
              if ac.size % 2 or payload_len_in_bits % 2:
                  raise ValueError('access code e payload devem ter comprimento par')
              self.codes = np.stack([self._rot(ac, k) for k in range(4)])
              self.ac_len = ac.size
              self.pl_len = int(payload_len_in_bits)
              self.frame_len = self.ac_len + self.pl_len
              self.tag_key = pmt.intern(tag_key)
              self.threshold = threshold
              if self.pl_len > 0:
                  # Sob os valores padrão (payload 0) o GRC instancia o bloco só para
                  # inspecionar as portas; set_output_multiple(0) daria erro ali.
                  self.set_output_multiple(self.pl_len)

          @staticmethod
          def _rot(x, k):
              """Aplica k rotações de +90° ao fluxo de LLRs (cada par de LLRs = 1 símbolo)."""
              y = x.reshape(-1, 2).copy()
              for _ in range(k % 4):
                  a = y[:, 0].copy()
                  y[:, 0] = y[:, 1]
                  y[:, 1] = -a
              return y.reshape(-1)

          def forecast(self, noutput_items, ninputs):
              return [self.frame_len] * ninputs

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              if self.pl_len <= 0:
                  return 0
              if in0.size < self.frame_len or out0.size < self.pl_len:
                  return 0

              # Busca vetorizada: testa de uma vez todos os offsets em que ainda cabe
              # um quadro inteiro, limitada a um período de quadro por chamada.
              last = min(in0.size - self.frame_len, self.frame_len - 1)
              w = np.lib.stride_tricks.sliding_window_view(in0[:last + self.ac_len], self.ac_len)
              energy = np.abs(w).sum(axis=1)
              metric = (w @ self.codes.T) / np.where(energy > 0.0, energy, np.inf)[:, None]

              idx = np.flatnonzero(metric.max(axis=1) >= self.threshold)
              if idx.size == 0:
                  self.consume(0, last + 1)   # descarta o que já foi testado, guarda a cauda
                  return 0

              n = int(idx[0])                      # primeiro quadro do bloco
              k = int(np.argmax(metric[n]))        # qual das 4 rotações casou
              payload = in0[n + self.ac_len: n + self.frame_len]
              out0[:self.pl_len] = self._rot(payload, -k)   # desfaz a rotação
              self.consume(0, n + self.frame_len)
              self.add_item_tag(0, self.nitems_written(0), self.tag_key, pmt.from_long(self.pl_len))
              return self.pl_len
    access_code: access_code
    payload_len_in_bits: N
    tag_key: '"quadro"'
    threshold: '0.6'
  states: {}
- name: fec_extended_tagged_decoder_0
  id: fec_extended_tagged_decoder
  parameters:
    decoder_list: PC_dec
    lentagname: '"quadro"'
    mtu: '1500'
    puncpat: '''11'''
  states: {}
- name: fec_extended_tagged_encoder_0
  id: fec_extended_tagged_encoder
  parameters:
    encoder_list: PC_enc
    lentagname: '"quadro"'
    mtu: '1500'
    puncpat: '''11'''
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: Filtro de TX
    interp: sps
    taps: taps
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_1
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: taps/sps
    type: ccc
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    gui_hint: tabs@2:0,1,1,1
    samp_per_symbol: sps
    size: 100*sps
    srate: samp_rate
    type: complex
    ymax: '3.0'
    ymin: '-3.0'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@0:1,0,1,1
    name: '"teste"'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@1:1,1,1,1
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: baud_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@2:1,0,1,2
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@0:0,0,1,1
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"quadro"'
    type: float
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@2:0,0,1,1
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '2.0'
    ymin: '-2.0'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@2:0,2,1,1
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '10.0'
    ymin: '-10.0'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 3,0,20,1
    label0: Transmissor
    label1: Canal
    label2: Receptor
    num_tabs: '3'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_signal
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx_signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx_signal
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rx_signal
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_random_uniform_source_x_0, '0', blocks_file_sink_0_0, '0']
- [analog_random_uniform_source_x_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_costas_loop_cc_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_pack_k_bits_bb_1, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_stream_mux_0, '0', blocks_char_to_float_0, '0']
- [blocks_stream_mux_0, '0', blocks_throttle2_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_throttle2_0, '0', blocks_pack_k_bits_bb_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_stream_mux_0, '0']
- [blocks_vector_source_x_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [channels_channel_model_0, '0', qtgui_sink_x_0_0, '0']
- [channels_channel_model_0, '0', virtual_sink_1, '0']
- [digital_constellation_encoder_bc_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_constellation_soft_decoder_cf_0, '0', epy_block_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_soft_decoder_cf_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_sink_x_1, '0']
- [digital_crc32_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_crc32_bb_0, '0', epy_block_0, '1']
- [digital_crc32_bb_0_0, '0', fec_extended_tagged_encoder_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [epy_block_0_0, '0', fec_extended_tagged_decoder_0, '0']
- [epy_block_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [fec_extended_tagged_decoder_0, '0', digital_crc32_bb_0, '0']
- [fec_extended_tagged_decoder_0, '0', epy_block_0, '0']
- [fec_extended_tagged_encoder_0, '0', blocks_stream_mux_0, '1']
- [interp_fir_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', virtual_sink_0, '0']
- [interp_fir_filter_xxx_1, '0', analog_agc_xx_0, '0']
- [interp_fir_filter_xxx_1, '0', qtgui_eye_sink_x_0, '0']
- [interp_fir_filter_xxx_1, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0, '0', channels_channel_model_0, '0']
- [virtual_source_1, '0', interp_fir_filter_xxx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
