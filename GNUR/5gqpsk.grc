options:
  parameters:
    generate_options: qt_gui
    id: ook_3
    output_language: python
    title: OOK - versão 3
  states: {}

blocks:
- name: PC_dec
  id: variable_polar_decoder_sc_def
  parameters:
    block_size: '16'
    frozen_bit_positions: '[0,1,2,3,4,5,8,9]'
    frozen_bit_values: '[0,0,0,0,0,0,0,0]'
    ndim: '0'
    num_info_bits: '8'
  states: {}
- name: PC_enc
  id: variable_polar_encoder_def
  parameters:
    block_size: '16'
    frozen_bit_positions: '[0,1,2,3,4,5,8,9]'
    frozen_bit_values: '[0,0,0,0,0,0,0,0]'
    is_packed: 'False'
    ndim: '0'
    num_info_bits: '8'
  states: {}
- name: access_code
  id: variable
  parameters:
    value: '"11100001010110101110100010010011"'
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: bit_rate / 1
  states: {}
- name: bit_rate
  id: variable
  parameters:
    value: 800e3
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    start: '0.0'
    step: '0.01'
    stop: '2.0'
    value: '0.5'
    widget: slider
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: '40'
  states: {}
- name: qpsk
  id: variable_constellation
  parameters:
    const_points: '[0.0, 1.0]'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    sym_map: '[0, 1]'
    type: qpsk
  states: {}
- name: rrc_filter_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.25'
    gain: sps
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: baud_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud_rate * sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '50'
  states: {}
- name: taps
  id: variable
  parameters:
    value: np.array(rrc_filter_taps)
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: alice.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (4, payload_len)
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"quadro"'
    packet_len: 4 + payload_len
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: bit_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0xE1, 0x5A, 0xE8, 0x93)
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.001'
    freq_offset: '0.00000001'
    noise_voltage: noise_voltage
    seed: '0'
    taps: '1.0'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: 100*sps
    long_form: 'True'
    type: ff
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: qpsk
    npwr: '-1'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.basic_block):\n    def __init__(self, access_code=\"\", payload_len_in_bits=0):\n        gr.basic_block.__init__(\n            self,\n            name='Find Access Code',\n            in_sig=[np.uint8],\n            out_sig=[np.uint8],\n        )\n        self.access_code = np.array([int(b) for b in access_code])\n        self.payload_len_in_bits = payload_len_in_bits\n\n    def general_work(self, input_items, output_items):\n        in0 = input_items[0]\n        out0 = output_items[0]\n        ac_len = self.access_code.size\n        pl_len = self.payload_len_in_bits\n        if len(in0) < ac_len + pl_len:\n            return 0\n        if len(out0) < pl_len:\n    \t        return 0\n        if not np.array_equal(in0[:ac_len], self.access_code):\n           self.consume(0, 1)  # Não é o mais otimizado. :D\n           return 0\n        self.consume(0, ac_len + pl_len)\n        out0[:pl_len] = in0[ac_len: ac_len + pl_len]\n        return pl_len\n\n"
    access_code: access_code
    payload_len_in_bits: payload_len * 8
  states: {}
- name: fec_extended_tagged_decoder_0
  id: fec_extended_tagged_decoder
  parameters:
    decoder_list: PC_enc
    lentagname: packet_len
    mtu: '1500'
    puncpat: '''11'''
  states: {}
- name: fec_extended_tagged_encoder_0
  id: fec_extended_tagged_encoder
  parameters:
    encoder_list: PC_dec
    lentagname: packet_len
    mtu: '1500'
    puncpat: '''11'''
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: Filtro de TX
    interp: sps
    taps: taps
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_1
  id: interp_fir_filter_xxx
  parameters:
    comment: Filtro de RX (casado)
    interp: '1'
    taps: taps/sps
    type: fff
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    comment: Conecte usando `netcat localhost 2000`
    mode: '2'
    port: '2000'
    type: byte
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    gui_hint: tabs@1:2,1,1,1
    samp_per_symbol: sps
    size: 100*sps
    srate: samp_rate
    type: float
    ymax: '1.0'
    ymin: '-1.0'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@0:1,0,1,1
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@0:0,0,1,1
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"quadro"'
    type: float
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@1:2,0,1,1
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '2.0'
    ymin: '-0.25'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@1:3,0,1,2
    size: '1024'
    srate: bit_rate
    type: float
    ymax: '1.25'
    ymin: '-0.25'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,20,1
    label0: Transmissor
    label1: Receptor
    num_tabs: '2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_signal
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx_signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx_signal
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rx_signal
  states: {}

connections:
- [blocks_add_const_vxx_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_add_const_vxx_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0, '0', interp_fir_filter_xxx_1, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_file_source_0, '0', blocks_stream_mux_0, '1']
- [blocks_float_to_complex_0, '0', digital_constellation_soft_decoder_cf_0, '0']
- [blocks_pack_k_bits_bb_0, '0', network_tcp_sink_0, '0']
- [blocks_stream_mux_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', fec_extended_tagged_encoder_0, '0']
- [blocks_throttle2_0, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_throttle2_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_mux_0, '0']
- [channels_channel_model_0, '0', virtual_sink_1, '0']
- [dc_blocker_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [dc_blocker_xx_0, '0', qtgui_eye_sink_x_0, '0']
- [digital_constellation_encoder_bc_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_constellation_soft_decoder_cf_0, '0', fec_extended_tagged_decoder_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_add_const_vxx_0_0, '0']
- [epy_block_0, '0', blocks_pack_k_bits_bb_0, '0']
- [fec_extended_tagged_decoder_0, '0', epy_block_0, '0']
- [fec_extended_tagged_encoder_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', virtual_sink_0, '0']
- [interp_fir_filter_xxx_1, '0', dc_blocker_xx_0, '0']
- [virtual_source_0, '0', channels_channel_model_0, '0']
- [virtual_source_1, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
