options:
  parameters:
    generate_options: qt_gui
    id: qpsk_5g
    output_language: python
    title: QPSK - 5G
  states: {}

blocks:
- name: K
  id: variable
  parameters:
    value: '512'
  states: {}
- name: N
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: PC_dec
  id: variable_polar_decoder_sc_def
  parameters:
    block_size: N
    frozen_bit_positions: frozen_pos
    frozen_bit_values: frozen_val
    ndim: '0'
    num_info_bits: K
  states: {}
- name: PC_enc
  id: variable_polar_encoder_def
  parameters:
    block_size: N
    frozen_bit_positions: frozen_pos
    frozen_bit_values: frozen_val
    is_packed: 'False'
    ndim: '0'
    num_info_bits: K
  states: {}
- name: RelSeq
  id: variable
  parameters:
    value: np.array([0, 1, 2, 4, 8, 16, 32, 3, 5, 64, 9, 6, 17, 10, 18, 128, 12, 33, 65, 20, 256, 34, 24, 36, 7, 129, 66, 512, 11, 40, 68, 130, 19, 13, 48, 14, 72, 257, 21, 132, 35, 258, 26, 513, 80, 37, 25, 22, 136, 260, 264, 38, 514, 96, 67, 41, 144, 28, 69, 42, 516, 49, 74, 272, 160, 520, 288, 528, 192, 544, 70, 44, 131, 81, 50, 73, 15, 320, 133, 52, 23, 134, 384, 76, 137, 82, 56, 27, 97, 39, 259, 84, 138, 145, 261, 29, 43, 98, 515, 88, 140, 30, 146, 71, 262, 265, 161, 576, 45, 100, 640, 51, 148, 46, 75, 266, 273, 517, 104, 162, 53, 193, 152, 77, 164, 768, 268, 274, 518, 54, 83, 57, 521, 112, 135, 78, 289, 194, 85, 276, 522, 58, 168, 139, 99, 86, 60, 280, 89, 290, 529, 524, 196, 141, 101, 147, 176, 142, 530, 321, 31, 200, 90, 545, 292, 322, 532, 263, 149, 102, 105, 304, 296, 163, 92, 47, 267, 385, 546, 324, 208, 386, 150, 153, 165, 106, 55, 328, 536, 577, 548, 113, 154, 79, 269, 108, 578, 224, 166, 519, 552, 195, 270, 641, 523, 275, 580, 291, 59, 169, 560, 114, 277, 156, 87, 197, 116, 170, 61, 531, 525, 642, 281, 278, 526, 177, 293, 388, 91, 584, 769, 198, 172, 120, 201, 336, 62, 282, 143, 103, 178, 294, 93, 644, 202, 592, 323, 392, 297, 770, 107, 180, 151, 209, 284, 648, 94, 204, 298, 400, 608, 352, 325, 533, 155, 210, 305, 547, 300, 109, 184, 534, 537, 115, 167, 225, 326, 306, 772, 157, 656, 329, 110, 117, 212, 171, 776, 330, 226, 549, 538, 387, 308, 216, 416, 271, 279, 158, 337, 550, 672, 118, 332, 579, 540, 389, 173, 121, 553, 199, 784, 179, 228, 338, 312, 704, 390, 174, 554, 581, 393, 283, 122, 448, 353, 561, 203, 63, 340, 394, 527, 582, 556, 181, 295, 285, 232, 124, 205, 182, 643, 562, 286, 585, 299, 354, 211, 401, 185, 396, 344, 586, 645, 593, 535, 240, 206, 95, 327, 564, 800, 402, 356, 307, 301, 417, 213, 568, 832, 588, 186, 646, 404, 227, 896, 594, 418, 302, 649, 771, 360, 539, 111, 331, 214, 309, 188, 449, 217, 408, 609, 596, 551, 650, 229, 159, 420, 310, 541, 773, 610, 657, 333, 119, 600, 339, 218, 368, 652, 230, 391, 313, 450, 542, 334, 233, 555, 774, 175, 123, 658, 612, 341, 777, 220, 314, 424, 395, 673, 583, 355, 287, 183, 234, 125, 557, 660, 616, 342, 316, 241, 778, 563, 345, 452, 397, 403, 207, 674, 558, 785, 432, 357, 187, 236, 664, 624, 587, 780, 705, 126, 242, 565, 398, 346, 456, 358, 405, 303, 569, 244, 595, 189, 566, 676, 361, 706, 589, 215, 786, 647, 348, 419, 406, 464, 680, 801, 362, 590, 409, 570, 788, 597, 572, 219, 311, 708, 598, 601, 651, 421, 792, 802, 611, 602, 410, 231, 688, 653, 248, 369, 190, 364, 654, 659, 335, 480, 315, 221, 370, 613, 422, 425, 451, 614, 543, 235, 412, 343, 372, 775, 317, 222, 426, 453, 237, 559, 833, 804, 712, 834, 661, 808, 779, 617, 604, 433, 720, 816, 836, 347, 897, 243, 662, 454, 318, 675, 618, 898, 781, 376, 428, 665, 736, 567, 840, 625, 238, 359, 457, 399, 787, 591, 678, 434, 677, 349, 245, 458, 666, 620, 363, 127, 191, 782, 407, 436, 626, 571, 465, 681, 246, 707, 350, 599, 668, 790, 460, 249, 682, 573, 411, 803, 789, 709, 365, 440, 628, 689, 374, 423, 466, 793, 250, 371, 481, 574, 413, 603, 366, 468, 655, 900, 805, 615, 684, 710, 429, 794, 252, 373, 605, 848, 690, 713, 632, 482, 806, 427, 904, 414, 223, 663, 692, 835, 619, 472, 455, 796, 809, 714, 721, 837, 716, 864, 810, 606, 912, 722, 696, 377, 435, 817, 319, 621, 812, 484, 430, 838, 667, 488, 239, 378, 459, 622, 627, 437, 380, 818, 461, 496, 669, 679, 724, 841, 629, 351, 467, 438, 737, 251, 462, 442, 441, 469, 247, 683, 842, 738, 899, 670, 783, 849, 820, 728, 928, 791, 367, 901, 630, 685, 844, 633, 711, 253, 691, 824, 902, 686, 740, 850, 375, 444, 470, 483, 415, 485, 905, 795, 473, 634, 744, 852, 960, 865, 693, 797, 906, 715, 807, 474, 636, 694, 254, 717, 575, 913, 798, 811, 379, 697, 431, 607, 489, 866, 723, 486, 908, 718, 813, 476, 856, 839, 725, 698, 914, 752, 868, 819, 814, 439, 929, 490, 623, 671, 739, 916, 463, 843, 381, 497, 930, 821, 726, 961, 872, 492, 631, 729, 700, 443, 741, 845, 920, 382, 822, 851, 730, 498, 880, 742, 445, 471, 635, 932, 687, 903, 825, 500, 846, 745, 826, 732, 446, 962, 936, 475, 853, 867, 637, 907, 487, 695, 746, 828, 753, 854, 857, 504, 799, 255, 964, 909, 719, 477, 915, 638, 748, 944, 869, 491, 699, 754, 858, 478, 968, 383, 910, 815, 976, 870, 917, 727, 493, 873, 701, 931, 756, 860, 499, 731, 823, 922, 874, 918, 502, 933, 743, 760, 881, 494, 702, 921, 501, 876, 847, 992, 447, 733, 827, 934, 882, 937, 963, 747, 505, 855, 924, 734, 829, 965, 938, 884, 506, 749, 945, 966, 755, 859, 940, 830, 911, 871, 639, 888, 479, 946, 750, 969, 508, 861, 757, 970, 919, 875, 862, 758, 948, 977, 923, 972, 761, 877, 952, 495, 703, 935, 978, 883, 762, 503, 925, 878, 735, 993, 885, 939, 994, 980, 926, 764, 941, 967, 886, 831, 947, 507, 889, 984, 751, 942, 996, 971, 890, 509, 949, 973, 1000, 892, 950, 863, 759, 1008, 510, 979, 953, 763, 974, 954, 879, 981, 982, 927, 995, 765, 956, 887, 985, 997, 986, 943, 891, 998, 766, 511, 988, 1001, 951, 1002, 893, 975, 894, 1009, 955, 1004, 1010, 957, 983, 958, 987, 1012, 999, 1016, 767, 989, 1003, 990, 1005, 959, 1011, 1013, 895, 1006, 1014, 1017, 1018, 991, 1020, 1007, 1015, 1019, 1021, 1022, 1023])
  states: {}
- name: access_code
  id: variable
  parameters:
    value: '"11100001010110101110100010010011"'
  states: {}
- name: aquecimento_segundos
  id: variable
  parameters:
    value: '1'
  states: {}
- name: att_segundos
  id: variable
  parameters:
    value: '0.00125'
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: bit_rate / 1
  states: {}
- name: bit_rate
  id: variable
  parameters:
    value: 800e3
  states: {}
- name: epsilon
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    start: '0.99'
    step: '0.0001'
    stop: '1.01'
    value: '1.0'
    widget: eng_slider
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    start: '-0.002'
    step: '0.00001'
    stop: '0.002'
    value: '0.0'
    widget: eng_slider
  states: {}
- name: frozen_pos
  id: variable
  parameters:
    value: np.sort(RelSeq[RelSeq < N][:N-K])
  states: {}
- name: frozen_val
  id: variable
  parameters:
    value: np.zeros(N-K, dtype=int)
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    start: '0.0'
    step: '0.01'
    stop: '10.0'
    value: '0'
    widget: eng_slider
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: '1'
  states: {}
- name: qpsk
  id: variable_constellation
  parameters:
    const_points: '[0.0, 1.0]'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    sym_map: '[0, 1]'
    type: qpsk
  states: {}
- name: rrc_filter_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.25'
    gain: sps
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: baud_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud_rate * sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '3'
  states: {}
- name: sync_len
  id: variable
  parameters:
    value: '32'
  states: {}
- name: tag_name
  id: variable
  parameters:
    value: '"quadro"'
  states: {}
- name: taps
  id: variable
  parameters:
    value: np.array(rrc_filter_taps)
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: 1e3
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '256'
    minimum: '0'
    seed: '42'
    type: byte
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: alice.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: alice.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      constellation_qpsk() tem |z| = 2;
      o Costas espera amplitude unitaria
    const: '0.5'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      constellation_qpsk() tem |z| = 2;
      o Costas espera amplitude unitaria
    const: '1.2'
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (32, N)
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"quadro"'
    packet_len: K-32
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"quadro"'
    packet_len: K-32
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: bit_rate
    type: byte
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: bit_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0xE1, 0x5A, 0xE8, 0x93)
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: epsilon
    freq_offset: freq_offset
    noise_voltage: noise_voltage
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: qpsk
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: qpsk
    npwr: '-1'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 2*np.pi/200
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"quadro"'
    packed: 'False'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"quadro"'
    packed: 'False'
  states: {}
- name: digital_crc32_bb_0_0_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"quadro"'
    packed: 'False'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '0.01'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          """
          Find Access Code — invariante às quatro ambiguidades de fase da QPSK.

          Procura o access code no fluxo de LLRs correlacionando, em paralelo, contra
          as quatro versões do código correspondentes às rotações de 0°, 90°, 180° e
          270° da constelação. Ao encontrar, desfaz a rotação no payload antes de
          repassá-lo adiante, de modo que o Costas Loop pode travar em qualquer uma
          das quatro fases sem quebrar o enquadramento.
          """

          def __init__(self, access_code="", payload_len_in_bits=0, tag_key="", threshold=0.9):
              gr.basic_block.__init__(
                  self,
                  name='Find Access Code',
                  in_sig=[np.float32],
                  out_sig=[np.float32],
              )
              ac = np.array([2 * int(b) - 1 for b in access_code], dtype=np.float32)
              if ac.size % 2 or payload_len_in_bits % 2:
                  raise ValueError('access code e payload devem ter comprimento par')
              self.codes = np.stack([self._rot(ac, k) for k in range(4)])
              self.ac_len = ac.size
              self.pl_len = int(payload_len_in_bits)
              self.frame_len = self.ac_len + self.pl_len
              self.tag_key = pmt.intern(tag_key)
              self.threshold = threshold
              if self.pl_len > 0:
                  # Sob os valores padrão (payload 0) o GRC instancia o bloco só para
                  # inspecionar as portas; set_output_multiple(0) daria erro ali.
                  self.set_output_multiple(self.pl_len)

          @staticmethod
          def _rot(x, k):
              """Aplica k rotações de +90° ao fluxo de LLRs (cada par de LLRs = 1 símbolo)."""
              y = x.reshape(-1, 2).copy()
              for _ in range(k % 4):
                  a = y[:, 0].copy()
                  y[:, 0] = y[:, 1]
                  y[:, 1] = -a
              return y.reshape(-1)

          def forecast(self, noutput_items, ninputs):
              return [self.frame_len] * ninputs

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              if self.pl_len <= 0:
                  return 0
              if in0.size < self.frame_len or out0.size < self.pl_len:
                  return 0

              # Busca vetorizada: testa de uma vez todos os offsets em que ainda cabe
              # um quadro inteiro, limitada a um período de quadro por chamada.
              last = min(in0.size - self.frame_len, self.frame_len - 1)
              w = np.lib.stride_tricks.sliding_window_view(in0[:last + self.ac_len], self.ac_len)
              energy = np.abs(w).sum(axis=1)
              metric = (w @ self.codes.T) / np.where(energy > 0.0, energy, np.inf)[:, None]

              idx = np.flatnonzero(metric.max(axis=1) >= self.threshold)
              if idx.size == 0:
                  self.consume(0, last + 1)   # descarta o que já foi testado, guarda a cauda
                  return 0

              n = int(idx[0])                      # primeiro quadro do bloco
              k = int(np.argmax(metric[n]))        # qual das 4 rotações casou
              payload = in0[n + self.ac_len: n + self.frame_len]
              out0[:self.pl_len] = self._rot(payload, -k)   # desfaz a rotação
              self.consume(0, n + self.frame_len)
              self.add_item_tag(0, self.nitems_written(0), self.tag_key, pmt.from_long(self.pl_len))
              return self.pl_len
    access_code: access_code
    payload_len_in_bits: N
    tag_key: '"quadro"'
    threshold: '0.6'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import time
      from collections import deque

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          """
          Monitor de BLER, BER residual, vazão e goodput.

          Portas de entrada (todas uint8, bit a bit, com tags 'quadro' marcando
          o início de cada quadro; o valor da tag é o comprimento do quadro em
          bits):

          Porta 0: saída do decodificador FEC (RX), ANTES do CRC check. Usada
              pra contar quadros/bits recebidos (BLER/vazão) e pra extrair o
              conteúdo de bits de cada quadro decodificado (para a BER).

          Porta 1: saída do CRC Check (RX, check=True). Só os quadros que
              passaram no CRC chegam aqui. Usada só pra contar quadros/bits
              válidos (BLER/goodput).

          Porta 2: saída do CRC Add do TX (check=False) — ou seja, o bit stream
              de REFERÊNCIA, exatamente o que devia ter sido recebido, sem
              ruído/erro de canal. Usada pra calcular a BER residual, comparando
              cada quadro decodificado (porta 0) com o quadro de referência
              correspondente.

          Como a porta 2 é a saída do próprio transmissor, ela chega mais cedo
          do que o quadro decodificado equivalente na porta 0 (o RX tem atraso
          de sincronismo/decodificação). Por isso os quadros de referência
          completos são guardados numa fila (fila_referencia) e só consumidos
          quando o quadro decodificado correspondente chega. Antes do primeiro
          sincronismo, essa fila NÃO tem limite de tamanho — do contrário, um
          atraso de aquisição do RX (Costas loop / symbol sync) maior que o
          limite descartaria justamente os quadros de referência que
          corresponderiam ao primeiro quadro decodificado, forçando um
          sincronismo travado numa posição errada. Só depois de sincronizar
          pela primeira vez a fila passa a ter um teto (tamanho_max_fila_pos_sync),
          já que em regime permanente ela deve ficar sempre curta.

          Sincronização: como não existe nenhum índice explícito dizendo "isso é
          o quadro N", o bloco descobre o alinhamento certo procurando, dentro
          de uma janela de quadros de referência pendentes, aquele com menor
          distância de Hamming em relação ao quadro decodificado recebido. Uma
          vez sincronizado, assume-se alinhamento sequencial (1 quadro da fila
          por quadro decodificado) até que a taxa de erro de um quadro
          específico sugira que o alinhamento se perdeu, disparando uma nova
          busca.

          Saídas (float32):
          0 BLER janela    1 BLER total
          2 BER  janela    3 BER  total
          4 vazão janela   5 vazão total
          6 goodput janela 7 goodput total
          """

          def __init__(self, tag_name="quadro", taxa_relogio=800e3,
                       bits_por_quadro_tx=1056, janela_s=1.0,
                       aquecimento_s=0.0, imprimir=False,
                       janela_busca_quadros=50, limiar_dessincronismo=0.3):
              gr.basic_block.__init__(
                  self,
                  name="Monitor BLER/BER/vazão",
                  in_sig=[np.uint8, np.uint8, np.uint8],
                  out_sig=[np.float32] * 8,
              )
              self.chave_tag = pmt.intern(tag_name)
              self.taxa_relogio = float(taxa_relogio)
              self.bits_por_quadro_tx = int(bits_por_quadro_tx)
              self.janela_s = float(janela_s)
              self.aquecimento_s = float(aquecimento_s)
              self.imprimir = bool(imprimir)
              self.em_aquecimento = self.aquecimento_s > 0
              self.janela_busca_quadros = int(janela_busca_quadros)
              self.limiar_dessincronismo = float(limiar_dessincronismo)

              # contadores acumulados desde o início (ou desde o fim do aquecimento)
              self.relogio = 0                # itens (bits) consumidos na porta 0
              self.quadros_recebidos = 0      # quadros que chegaram ao CRC (porta 0)
              self.quadros_validos = 0        # quadros que passaram no CRC (porta 1)
              self.bits_recebidos = 0         # bits dos quadros recebidos (com CRC)
              self.bits_validos = 0           # bits úteis dos quadros válidos
              self.bits_comparados = 0        # total de bits comparados p/ BER
              self.bits_errados = 0           # bits diferentes entre RX e referência

              # "foto" dos contadores no momento do último relatório, para
              # calcular só o que aconteceu na janela atual (por subtração)
              self.contadores_ultimo_relatorio = (0, 0, 0, 0, 0, 0, 0)
              self.tempo_parede_inicio = time.monotonic()
              self.tempo_parede_ultimo_relatorio = self.tempo_parede_inicio
              self.proximo_relatorio_em_s = self.janela_s

              # estado da extração de quadros completos (porta 0 = RX decodificado,
              # porta 2 = referência do TX) a partir do stream de bits + tags
              self._comprimento_quadro_em_andamento = {0: None, 2: None}
              self._bits_quadro_em_andamento = {0: [], 2: []}

              # fila de quadros de referência recebidos e ainda não usados numa
              # comparação. Sem limite (None) até o primeiro sincronismo, pra não
              # descartar justamente os quadros que o primeiro quadro decodificado
              # vai precisar (o atraso de aquisição do RX pode ser grande). Depois
              # de sincronizar, passa a ter teto — em regime permanente a fila
              # deve ficar sempre curta, então isso só evita crescimento
              # descontrolado se o RX parar de decodificar quadros.
              self.tamanho_max_fila_pos_sincronismo = self.janela_busca_quadros * 4
              self.fila_referencia = deque()
              self.sincronizado = False

          def forecast(self, noutput_items, ninputs):
              # Não exige um mínimo de itens de entrada: o bloco só reporta
              # quando alguma das portas trouxer dados, e não fica em polling.
              return [0, 0, 0]

          # ------------------------------------------------------------------
          # extração de quadros completos a partir do stream de bits + tags
          # ------------------------------------------------------------------
          def _extrair_quadros_completos(self, porta, dados):
              """
              Recebe o array de bits novos de uma porta nesta chamada e devolve
              a lista de quadros completos (arrays numpy de bits) que puderam
              ser fechados. O que ainda estiver incompleto fica guardado em
              self._bits_quadro_em_andamento[porta] para a próxima chamada, já
              que um quadro pode chegar picotado em várias chamadas.
              """
              quadros_completos = []
              n = len(dados)
              if n == 0:
                  return quadros_completos

              tags = self.get_tags_in_window(porta, 0, n, self.chave_tag)
              comprimento_por_posicao = {
                  tag.offset - self.nitems_read(porta): pmt.to_long(tag.value)
                  for tag in tags
              }

              posicao = 0
              while posicao < n:
                  if self._comprimento_quadro_em_andamento[porta] is None:
                      if posicao not in comprimento_por_posicao:
                          # bits soltos antes do primeiro quadro reconhecido
                          # (só deve acontecer logo no início da execução)
                          posicao += 1
                          continue
                      self._comprimento_quadro_em_andamento[porta] = (
                          comprimento_por_posicao[posicao])
                      self._bits_quadro_em_andamento[porta] = []

                  faltam = (self._comprimento_quadro_em_andamento[porta]
                            - len(self._bits_quadro_em_andamento[porta]))
                  pegar = min(faltam, n - posicao)
                  self._bits_quadro_em_andamento[porta].extend(
                      dados[posicao:posicao + pegar].tolist())
                  posicao += pegar

                  if (len(self._bits_quadro_em_andamento[porta])
                          == self._comprimento_quadro_em_andamento[porta]):
                      quadros_completos.append(np.array(
                          self._bits_quadro_em_andamento[porta], dtype=np.uint8))
                      self._comprimento_quadro_em_andamento[porta] = None
                      self._bits_quadro_em_andamento[porta] = []

              return quadros_completos

          # ------------------------------------------------------------------
          # alinhamento do quadro decodificado com a fila de referência
          # ------------------------------------------------------------------
          def _distancia_hamming(self, quadro_a, quadro_b):
              tamanho = min(len(quadro_a), len(quadro_b))
              erros = int(np.sum(quadro_a[:tamanho] != quadro_b[:tamanho]))
              return erros, tamanho

          def _buscar_melhor_alinhamento(self, quadro_rx, quantidade_a_pesquisar):
              """
              Procura, dentro dos primeiros `quantidade_a_pesquisar` quadros de
              referência pendentes, o que tem menor distância de Hamming em
              relação ao quadro decodificado. Descarta da fila tudo que vier
              antes do encontrado (referência "perdida", nunca vai ser usada)
              junto com o próprio quadro encontrado (já consumido nesta
              comparação).

              `quantidade_a_pesquisar` é quem decide o alcance da busca: no
              sincronismo inicial, deve ser a fila inteira (o atraso de
              aquisição do RX pode ser grande e ainda desconhecido); nas
              re-buscas após já estar sincronizado, uma janela pequena
              (janela_busca_quadros) já basta, porque o drift esperado é só
              local.

              Retorna (quadro_referencia_usado, distancia) ou (None, None) se a
              fila ainda não tiver quadros suficientes pra buscar.
              """
              melhor_indice = None
              melhor_distancia = None
              limite = min(len(self.fila_referencia), quantidade_a_pesquisar)
              for indice in range(limite):
                  distancia, _ = self._distancia_hamming(
                      quadro_rx, self.fila_referencia[indice])
                  if melhor_distancia is None or distancia < melhor_distancia:
                      melhor_distancia = distancia
                      melhor_indice = indice

              if melhor_indice is None:
                  return None, None

              quadro_referencia_usado = None
              for _ in range(melhor_indice + 1):
                  quadro_referencia_usado = self.fila_referencia.popleft()

              return quadro_referencia_usado, melhor_distancia

          def _comparar_com_referencia(self, quadro_rx):
              """
              Retorna (bits_errados, bits_comparados) desse quadro decodificado
              em relação à referência, ou (0, 0) se ainda não há referência
              suficiente na fila pra comparar.
              """
              if not self.fila_referencia:
                  return 0, 0

              if not self.sincronizado:
                  # busca inicial: varre a fila INTEIRA, não só uma janela.
                  # O atraso de aquisição do RX ainda é desconhecido aqui, e
                  # pode facilmente passar de janela_busca_quadros quadros.
                  quadro_referencia, _ = self._buscar_melhor_alinhamento(
                      quadro_rx, quantidade_a_pesquisar=len(self.fila_referencia))
                  if quadro_referencia is None:
                      return 0, 0
                  self.sincronizado = True
                  return self._distancia_hamming(quadro_rx, quadro_referencia)

              quadro_referencia = self.fila_referencia.popleft()
              erros, tamanho = self._distancia_hamming(quadro_rx, quadro_referencia)

              if tamanho and erros / tamanho > self.limiar_dessincronismo:
                  # taxa de erro suspeita demais: provável perda de alinhamento.
                  # devolve a referência já retirada e tenta achar uma posição
                  # melhor considerando também ela. Aqui sim usamos só uma
                  # janela pequena (janela_busca_quadros): já estávamos
                  # sincronizados, então o desalinhamento esperado é local.
                  self.fila_referencia.appendleft(quadro_referencia)
                  candidata, distancia_candidata = self._buscar_melhor_alinhamento(
                      quadro_rx, quantidade_a_pesquisar=self.janela_busca_quadros)
                  if candidata is not None and distancia_candidata < erros:
                      quadro_referencia = candidata
                      erros, tamanho = self._distancia_hamming(
                          quadro_rx, quadro_referencia)

              return erros, tamanho

          # ------------------------------------------------------------------
          # laço principal (roda no general_work, thread do scheduler)
          # ------------------------------------------------------------------
          def general_work(self, input_items, output_items):
              # --- porta 0: quadros que chegam ao decodificador (antes do CRC) ---
              itens_porta_0 = len(input_items[0])
              quadros_rx_completos = []
              if itens_porta_0:
                  for tag in self.get_tags_in_window(
                          0, 0, itens_porta_0, self.chave_tag):
                      self.quadros_recebidos += 1
                      self.bits_recebidos += pmt.to_long(tag.value)
                  self.relogio += itens_porta_0
                  quadros_rx_completos = self._extrair_quadros_completos(
                      0, input_items[0])
                  self.consume(0, itens_porta_0)

              # --- porta 1: quadros que passaram no CRC (RX) ---
              itens_porta_1 = len(input_items[1])
              if itens_porta_1:
                  for tag in self.get_tags_in_window(
                          1, 0, itens_porta_1, self.chave_tag):
                      self.quadros_validos += 1
                      self.bits_validos += pmt.to_long(tag.value)
                  self.consume(1, itens_porta_1)

              # --- porta 2: referência (saída do CRC Add do TX, sem canal) ---
              itens_porta_2 = len(input_items[2])
              if itens_porta_2:
                  quadros_referencia_completos = self._extrair_quadros_completos(
                      2, input_items[2])
                  self.fila_referencia.extend(quadros_referencia_completos)
                  if self.sincronizado:
                      # só depois de sincronizado impomos um teto: antes disso a
                      # fila precisa poder crescer o quanto for necessário pra
                      # cobrir o atraso de aquisição do RX
                      while len(self.fila_referencia) > self.tamanho_max_fila_pos_sincronismo:
                          self.fila_referencia.popleft()
                  self.consume(2, itens_porta_2)

              # --- compara cada quadro decodificado com a referência (BER) ---
              for quadro_rx in quadros_rx_completos:
                  erros, tamanho = self._comparar_com_referencia(quadro_rx)
                  self.bits_comparados += tamanho
                  self.bits_errados += erros

              tempo_sinal_s = self.relogio / self.taxa_relogio

              if self.em_aquecimento and tempo_sinal_s >= self.aquecimento_s:
                  self.em_aquecimento = False
                  self.relogio = 0
                  self.quadros_recebidos = 0
                  self.quadros_validos = 0
                  self.bits_recebidos = 0
                  self.bits_validos = 0
                  self.bits_comparados = 0
                  self.bits_errados = 0
                  self.fila_referencia = deque()
                  self.sincronizado = False
                  self.contadores_ultimo_relatorio = (0, 0, 0, 0, 0, 0, 0)
                  self.tempo_parede_inicio = time.monotonic()
                  self.tempo_parede_ultimo_relatorio = self.tempo_parede_inicio
                  self.proximo_relatorio_em_s = self.janela_s
                  if self.imprimir:
                      print(f"[aquecimento] {tempo_sinal_s:.2f}s de sinal "
                            f"descartados; contadores zerados", flush=True)
                  return 0

              pode_escrever_saida = len(output_items[0]) >= 1
              if tempo_sinal_s >= self.proximo_relatorio_em_s and pode_escrever_saida:
                  self.proximo_relatorio_em_s = (
                      tempo_sinal_s // self.janela_s + 1) * self.janela_s
                  for indice_saida, valor in enumerate(self._montar_relatorio()):
                      output_items[indice_saida][0] = valor
                  return 1
              return 0

          # ------------------------------------------------------------------
          # cálculo das métricas e montagem do relatório
          # ------------------------------------------------------------------
          def _calcular_metricas(self, itens_no_periodo, quadros_recebidos,
                                  quadros_validos, bits_recebidos, bits_validos,
                                  bits_comparados, bits_errados):
              tempo_s = itens_no_periodo / self.taxa_relogio
              quadros_esperados = itens_no_periodo / self.bits_por_quadro_tx
              bler = (1.0 - quadros_validos / quadros_recebidos
                      if quadros_recebidos else float("nan"))
              fer = (1.0 - quadros_validos / quadros_esperados
                     if quadros_esperados else float("nan"))
              ber = (bits_errados / bits_comparados
                     if bits_comparados else float("nan"))
              vazao_bps = bits_recebidos / tempo_s if tempo_s else 0.0
              goodput_bps = bits_validos / tempo_s if tempo_s else 0.0
              return (tempo_s, quadros_esperados, bler, fer, ber, vazao_bps,
                      goodput_bps)

          def _montar_relatorio(self):
              agora = time.monotonic()
              (relogio_anterior, quadros_recebidos_anterior,
               quadros_validos_anterior, bits_recebidos_anterior,
               bits_validos_anterior, bits_comparados_anterior,
               bits_errados_anterior) = self.contadores_ultimo_relatorio

              # métricas da janela (delta desde o último relatório)
              (tempo_s_janela, quadros_esperados_janela, bler_janela, fer_janela,
               ber_janela, vazao_bps_janela, goodput_bps_janela) = (
                  self._calcular_metricas(
                      self.relogio - relogio_anterior,
                      self.quadros_recebidos - quadros_recebidos_anterior,
                      self.quadros_validos - quadros_validos_anterior,
                      self.bits_recebidos - bits_recebidos_anterior,
                      self.bits_validos - bits_validos_anterior,
                      self.bits_comparados - bits_comparados_anterior,
                      self.bits_errados - bits_errados_anterior,
                  ))

              # métricas totais (acumuladas desde o início)
              (tempo_s_total, quadros_esperados_total, bler_total, fer_total,
               ber_total, vazao_bps_total, goodput_bps_total) = (
                  self._calcular_metricas(
                      self.relogio,
                      self.quadros_recebidos,
                      self.quadros_validos,
                      self.bits_recebidos,
                      self.bits_validos,
                      self.bits_comparados,
                      self.bits_errados,
                  ))

              valores_saida = [
                  bler_janela, bler_total,
                  ber_janela, ber_total,
                  vazao_bps_janela, vazao_bps_total,
                  goodput_bps_janela, goodput_bps_total,
              ]

              if self.imprimir:
                  print(
                      f"[janela] sinal={tempo_s_janela:7.2f}s  "
                      f"esperados={quadros_esperados_janela:9.1f}  "
                      f"BLER={bler_janela:.3e} FER={fer_janela:.3e} "
                      f"BER={ber_janela:.3e}  "
                      f"vazão={vazao_bps_janela / 1e3:7.1f} kb/s "
                      f"goodput={goodput_bps_janela / 1e3:7.1f} kb/s",
                      flush=True,
                  )
                  print(
                      f"[total ] sinal={tempo_s_total:7.2f}s  "
                      f"esperados={quadros_esperados_total:9.1f}  "
                      f"BLER={bler_total:.3e} FER={fer_total:.3e} "
                      f"BER={ber_total:.3e}  "
                      f"vazão={vazao_bps_total / 1e3:7.1f} kb/s "
                      f"goodput={goodput_bps_total / 1e3:7.1f} kb/s",
                      flush=True,
                  )

              self.contadores_ultimo_relatorio = (
                  self.relogio, self.quadros_recebidos, self.quadros_validos,
                  self.bits_recebidos, self.bits_validos, self.bits_comparados,
                  self.bits_errados)
              self.tempo_parede_ultimo_relatorio = agora
              return valores_saida
    aquecimento_s: '1.0'
    bits_por_quadro_tx: sync_len + N
    imprimir: 'False'
    janela_busca_quadros: '2000'
    janela_s: '0.0125'
    limiar_dessincronismo: '0.0000125'
    tag_name: '"quadro"'
    taxa_relogio: bit_rate
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      import time

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          """
          Monitor de vazão e goodput.

          Portas de entrada (uint8, bit a bit, com tags 'quadro' marcando o
          início de cada quadro; o valor da tag é o comprimento do quadro em
          bits):

          Porta 0: saída do decodificador FEC (RX), ANTES do CRC check. Usada
              pra contar bits recebidos (vazão) e como relógio de sinal (cada
              item vale 1/taxa_relogio segundos).

          Porta 1: saída do CRC Check (RX, check=True). Só os quadros que
              passaram no CRC chegam aqui, já sem os bits de CRC (packed=False).
              Usada pra contar bits úteis (goodput).

          A cada janela_s segundos de sinal, emite (e opcionalmente imprime):
              0 vazão janela [bit/s]    
              1 vazão total [bit/s]
              2 goodput janela [bit/s]  
              3 goodput total [bit/s]
          """

          def __init__(self, tag_name="quadro", taxa_relogio=800e3,
                       janela_s=1.0, aquecimento_s=0.0, imprimir=False):
              gr.basic_block.__init__(
                  self,
                  name="Monitor Vazão/Goodput",
                  in_sig=[np.uint8, np.uint8],
                  out_sig=[np.float32] * 4,
              )
              self.chave_tag = pmt.intern(tag_name)
              self.taxa_relogio = float(taxa_relogio)
              self.janela_s = float(janela_s)
              self.aquecimento_s = float(aquecimento_s)
              self.imprimir = bool(imprimir)
              self.em_aquecimento = self.aquecimento_s > 0

              # contadores acumulados desde o início (ou desde o fim do aquecimento)
              self.relogio = 0          # itens (bits) consumidos na porta 0
              self.bits_recebidos = 0   # bits dos quadros recebidos (com CRC)
              self.bits_validos = 0     # bits úteis dos quadros válidos

              # "foto" dos contadores no momento do último relatório, para
              # calcular só o que aconteceu na janela atual (por subtração)
              self.contadores_ultimo_relatorio = (0, 0, 0)
              self.proximo_relatorio_em_s = self.janela_s

          def forecast(self, noutput_items, ninputs):
              # Não exige um mínimo de itens de entrada: o bloco só reporta
              # quando alguma das portas trouxer dados, e não fica em polling.
              return [0, 0]

          def general_work(self, input_items, output_items):
              itens_porta_0 = len(input_items[0])
              if itens_porta_0:
                  for tag in self.get_tags_in_window(
                          0, 0, itens_porta_0, self.chave_tag):
                      self.bits_recebidos += pmt.to_long(tag.value)
                  self.relogio += itens_porta_0
                  self.consume(0, itens_porta_0)

              itens_porta_1 = len(input_items[1])
              if itens_porta_1:
                  for tag in self.get_tags_in_window(
                          1, 0, itens_porta_1, self.chave_tag):
                      self.bits_validos += pmt.to_long(tag.value)
                  self.consume(1, itens_porta_1)

              tempo_sinal_s = self.relogio / self.taxa_relogio

              if self.em_aquecimento and tempo_sinal_s >= self.aquecimento_s:
                  self.em_aquecimento = False
                  self.relogio = 0
                  self.bits_recebidos = 0
                  self.bits_validos = 0
                  self.contadores_ultimo_relatorio = (0, 0, 0)
                  self.proximo_relatorio_em_s = self.janela_s
                  if self.imprimir:
                      print(f"[aquecimento] {tempo_sinal_s:.2f}s de sinal "
                            f"descartados; contadores zerados", flush=True)
                  return 0

              pode_escrever_saida = len(output_items[0]) >= 1
              if tempo_sinal_s >= self.proximo_relatorio_em_s and pode_escrever_saida:
                  self.proximo_relatorio_em_s = (
                      tempo_sinal_s // self.janela_s + 1) * self.janela_s
                  for indice_saida, valor in enumerate(self.montar_relatorio()):
                      output_items[indice_saida][0] = valor
                  return 1
              return 0

          def calcular_taxas(self, itens_no_periodo, bits_recebidos, bits_validos):
              tempo_s = itens_no_periodo / self.taxa_relogio
              vazao_bps = bits_recebidos / tempo_s if tempo_s else 0.0
              goodput_bps = bits_validos / tempo_s if tempo_s else 0.0
              return tempo_s, vazao_bps, goodput_bps

          def montar_relatorio(self):
              (relogio_anterior, bits_recebidos_anterior,
               bits_validos_anterior) = self.contadores_ultimo_relatorio

              tempo_s_janela, vazao_bps_janela, goodput_bps_janela = (
                  self.calcular_taxas(
                      self.relogio - relogio_anterior,
                      self.bits_recebidos - bits_recebidos_anterior,
                      self.bits_validos - bits_validos_anterior,
                  ))
              tempo_s_total, vazao_bps_total, goodput_bps_total = (
                  self.calcular_taxas(
                      self.relogio, self.bits_recebidos, self.bits_validos))

              valores_saida = [
                  vazao_bps_janela, vazao_bps_total,
                  goodput_bps_janela, goodput_bps_total,
              ]

              if self.imprimir:
                  print(
                      f"[janela] sinal={tempo_s_janela:7.2f}s  "
                      f"vazão={vazao_bps_janela / 1e3:7.1f} kb/s "
                      f"goodput={goodput_bps_janela / 1e3:7.1f} kb/s",
                      flush=True,
                  )
                  print(
                      f"[total ] sinal={tempo_s_total:7.2f}s  "
                      f"vazão={vazao_bps_total / 1e3:7.1f} kb/s "
                      f"goodput={goodput_bps_total / 1e3:7.1f} kb/s",
                      flush=True,
                  )

              self.contadores_ultimo_relatorio = (
                  self.relogio, self.bits_recebidos, self.bits_validos)
              return valores_saida
    aquecimento_s: aquecimento_segundos
    imprimir: 'False'
    janela_s: att_segundos
    tag_name: tag_name
    taxa_relogio: bit_rate
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |-
      import time

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          """
          Monitor de BER (Bit Error Rate).

          Portas de entrada (uint8, bit a bit, com tags 'quadro' marcando o
          início de cada quadro; o valor da tag é o comprimento do quadro em
          bits):

          Porta 0: saída do decodificador FEC (RX), ANTES do CRC check.
              Quadro decodificado, com erro ou não.
          Porta 1: saída do CRC Add do TX (check=False) regerada a partir do
              mesmo arquivo conhecido, ou seja, o bit stream de REFERÊNCIA:
              exatamente o que devia ter sido recebido, sem ruído/erro de canal.

          Os quadros completos de cada porta são REALINHADOS entre si por
          distância de Hamming (em vez de um pareamento cego FIFO 1-para-1):
          para cada quadro recebido (porta 0) o bloco procura, dentro de uma
          janela dos próximos quadros de referência (porta 1) ainda não
          usados, aquele que tiver a menor distância de Hamming normalizada.

              - Se o melhor candidato tiver distância aceitável (abaixo de
                `limiar_descarte`), os quadros de referência anteriores a ele
                na janela são descartados (interpretados como quadros que se
                perderam do lado do RX -- ex.: o detector de quadro/decoder
                não produziu saída para eles) e o par é contabilizado.
              - Se nenhum candidato da janela for plausível (todas as
                distâncias próximas do nível aleatório, ~0.5), o quadro de
                RX é descartado sem ser contado, por ser interpretado como um
                quadro espúrio (falso sync) sem correspondente na referência.

          Isso substitui o pareamento simples por ordem de chegada que
          vazão/goodput e BLER ainda usam, e sobrevive a perda pontual de
          quadros em uma das pontas sem deslocar todos os pares seguintes.

          A cada janela_s segundos de sinal, emite (e opcionalmente imprime):
              0 BER janela
              1 BER total
          """

          def __init__(self, tag_name="quadro", taxa_relogio=800e3,
                       janela_s=1.0, aquecimento_s=0.0, imprimir=False,
                       janela_busca=5, limiar_descarte=0.4):
              gr.basic_block.__init__(
                  self,
                  name="Monitor BER",
                  in_sig=[np.uint8, np.uint8],
                  out_sig=[np.float32, np.float32],
              )
              self.chave_tag = pmt.intern(tag_name)
              self.taxa_relogio = float(taxa_relogio)
              self.janela_s = float(janela_s)
              self.aquecimento_s = float(aquecimento_s)
              self.imprimir = bool(imprimir)
              self.em_aquecimento = self.aquecimento_s > 0

              # quantos quadros de referência olhar à frente ao procurar o
              # melhor casamento para o quadro de RX corrente
              self.janela_busca = max(1, int(janela_busca))
              # distância de Hamming normalizada (0 a 1) acima da qual um
              # candidato é considerado "não é o mesmo quadro" (nível de
              # erro aleatório fica em torno de 0.5)
              self.limiar_descarte = float(limiar_descarte)

              # contadores acumulados desde o início (ou desde o fim do aquecimento)
              self.relogio = 0            # itens (bits) consumidos na porta 0
              self.bits_comparados = 0    # bits pareados entre as duas portas
              self.bits_errados = 0       # bits divergentes entre rx e referência
              self.quadros_perdidos = 0   # quadros de referência pulados no realinhamento
              self.quadros_espurios = 0   # quadros de rx descartados por falta de candidato

              # "foto" dos contadores no momento do último relatório, para
              # calcular só o que aconteceu na janela atual (por subtração)
              self.contadores_ultimo_relatorio = (0, 0, 0)
              self.proximo_relatorio_em_s = self.janela_s

              # remontagem de quadros por tag, igual aos outros monitores
              self._comprimento_quadro_em_andamento = {0: None, 1: None}
              self._bits_quadro_em_andamento = {0: [], 1: []}
              # quadros completos ainda não pareados, por porta
              self._fila_quadros = {0: [], 1: []}

          def forecast(self, noutput_items, ninputs):
              # Não exige um mínimo de itens de entrada: o bloco só reporta
              # quando alguma das portas trouxer dados, e não fica em polling.
              return [0, 0]

          def extrair_quadros_completos(self, porta, dados):
              n = len(dados)
              if n == 0:
                  return

              tags = self.get_tags_in_window(porta, 0, n, self.chave_tag)
              comprimento_por_posicao = {
                  tag.offset - self.nitems_read(porta): pmt.to_long(tag.value)
                  for tag in tags
              }

              posicao = 0
              while posicao < n:
                  if self._comprimento_quadro_em_andamento[porta] is None:
                      if posicao not in comprimento_por_posicao:
                          posicao += 1
                          continue
                      self._comprimento_quadro_em_andamento[porta] = (
                          comprimento_por_posicao[posicao])
                      self._bits_quadro_em_andamento[porta] = []

                  faltam = (self._comprimento_quadro_em_andamento[porta]
                            - len(self._bits_quadro_em_andamento[porta]))
                  pegar = min(faltam, n - posicao)
                  self._bits_quadro_em_andamento[porta].extend(
                      dados[posicao:posicao + pegar].tolist())
                  posicao += pegar

                  if (len(self._bits_quadro_em_andamento[porta])
                          == self._comprimento_quadro_em_andamento[porta]):
                      self._fila_quadros[porta].append(np.array(
                          self._bits_quadro_em_andamento[porta], dtype=np.uint8))
                      self._comprimento_quadro_em_andamento[porta] = None
                      self._bits_quadro_em_andamento[porta] = []

          def _distancia_normalizada(self, quadro_a, quadro_b):
              tamanho = min(len(quadro_a), len(quadro_b))
              if tamanho == 0:
                  return None, 0
              distancia = int(np.sum(quadro_a[:tamanho] != quadro_b[:tamanho]))
              return distancia / tamanho, tamanho

          def parear_e_contar(self):
              fila_rx = self._fila_quadros[0]
              fila_ref = self._fila_quadros[1]

              while fila_rx and fila_ref:
                  quadro_rx = fila_rx[0]
                  janela = fila_ref[:self.janela_busca]
                  janela_incompleta = len(janela) < self.janela_busca

                  melhor_indice = None
                  melhor_distancia = None
                  for indice, quadro_ref in enumerate(janela):
                      distancia, _ = self._distancia_normalizada(quadro_rx, quadro_ref)
                      if distancia is None:
                          continue
                      if melhor_distancia is None or distancia < melhor_distancia:
                          melhor_distancia = distancia
                          melhor_indice = indice

                  if melhor_indice is None:
                      # nenhum quadro de referência utilizável na janela ainda
                      break

                  if melhor_distancia > self.limiar_descarte:
                      if janela_incompleta:
                          # a janela ainda não está completa: aguarda mais
                          # quadros de referência chegarem antes de decidir,
                          # pois o casamento certo pode ainda não ter aparecido
                          break
                      # nenhum candidato plausível na janela cheia: quadro de
                      # RX é tratado como espúrio e descartado sem contar
                      fila_rx.pop(0)
                      self.quadros_espurios += 1
                      if self.imprimir:
                          print(f"[resync] quadro rx descartado (sem candidato "
                                f"plausível, melhor dist={melhor_distancia:.2f})",
                                flush=True)
                      continue

                  # quadros de referência antes do casamento correspondem a
                  # quadros perdidos do lado do RX -- descarta-os
                  quadros_pulados = melhor_indice
                  for _ in range(quadros_pulados):
                      fila_ref.pop(0)
                  if quadros_pulados:
                      self.quadros_perdidos += quadros_pulados
                      if self.imprimir:
                          print(f"[resync] {quadros_pulados} quadro(s) de "
                                f"referência pulado(s) (quadro perdido no rx)",
                                flush=True)

                  quadro_ref = fila_ref.pop(0)
                  fila_rx.pop(0)
                  _, tamanho = self._distancia_normalizada(quadro_rx, quadro_ref)
                  self.bits_errados += int(
                      np.sum(quadro_rx[:tamanho] != quadro_ref[:tamanho]))
                  self.bits_comparados += tamanho

          def general_work(self, input_items, output_items):
              itens_porta_0 = len(input_items[0])
              if itens_porta_0:
                  self.relogio += itens_porta_0
                  self.extrair_quadros_completos(0, input_items[0])
                  self.consume(0, itens_porta_0)

              itens_porta_1 = len(input_items[1])
              if itens_porta_1:
                  self.extrair_quadros_completos(1, input_items[1])
                  self.consume(1, itens_porta_1)

              self.parear_e_contar()

              tempo_sinal_s = self.relogio / self.taxa_relogio

              if self.em_aquecimento and tempo_sinal_s >= self.aquecimento_s:
                  self.em_aquecimento = False
                  self.relogio = 0
                  self.bits_comparados = 0
                  self.bits_errados = 0
                  self.quadros_perdidos = 0
                  self.quadros_espurios = 0
                  self.contadores_ultimo_relatorio = (0, 0, 0)
                  self.proximo_relatorio_em_s = self.janela_s
                  self._fila_quadros = {0: [], 1: []}
                  if self.imprimir:
                      print(f"[aquecimento] {tempo_sinal_s:.2f}s de sinal "
                            f"descartados; contadores zerados", flush=True)
                  return 0

              pode_escrever_saida = len(output_items[0]) >= 1
              if tempo_sinal_s >= self.proximo_relatorio_em_s and pode_escrever_saida:
                  self.proximo_relatorio_em_s = (
                      tempo_sinal_s // self.janela_s + 1) * self.janela_s
                  for indice_saida, valor in enumerate(self.montar_relatorio()):
                      output_items[indice_saida][0] = valor
                  return 1
              return 0

          def calcular_ber(self, bits_comparados, bits_errados):
              if not bits_comparados:
                  return float("nan")
              return bits_errados / bits_comparados

          def montar_relatorio(self):
              (relogio_anterior, comparados_anterior, errados_anterior) = (
                  self.contadores_ultimo_relatorio)

              ber_janela = self.calcular_ber(
                  self.bits_comparados - comparados_anterior,
                  self.bits_errados - errados_anterior,
              )
              ber_total = self.calcular_ber(
                  self.bits_comparados, self.bits_errados)

              if self.imprimir:
                  print(
                      f"[janela] comparados={self.bits_comparados - comparados_anterior:7d} "
                      f"errados={self.bits_errados - errados_anterior:7d}  "
                      f"BER={ber_janela:.3e}",
                      flush=True,
                  )
                  print(
                      f"[total ] comparados={self.bits_comparados:7d} "
                      f"errados={self.bits_errados:7d}  "
                      f"BER={ber_total:.3e}  "
                      f"quadros_perdidos={self.quadros_perdidos}  "
                      f"quadros_espurios={self.quadros_espurios}",
                      flush=True,
                  )

              self.contadores_ultimo_relatorio = (
                  self.relogio, self.bits_comparados, self.bits_errados)
              return [ber_janela, ber_total]
    aquecimento_s: aquecimento_segundos
    imprimir: 'True'
    janela_busca: '5'
    janela_s: att_segundos
    limiar_descarte: '0.4'
    tag_name: tag_name
    taxa_relogio: bit_rate
  states: {state: disabled}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |-
      import time

      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.basic_block):
          """
          Monitor de BLER (Block Error Rate).

          Portas de entrada (uint8, bit a bit, com tags 'quadro' marcando o
          início de cada quadro; o valor da tag é o comprimento do quadro em
          bits):

          Porta 0: saída do decodificador FEC (RX), ANTES do CRC check. Usada
              pra contar quadros recebidos.

          Porta 1: saída do CRC Check (RX, check=True). Só os quadros que
              passaram no CRC chegam aqui. Usada pra contar quadros válidos.

          A cada janela_s segundos de sinal, emite (e opcionalmente imprime):
              0 BLER janela   
              1 BLER total
          """

          def __init__(self, tag_name="quadro", taxa_relogio=800e3,
                       janela_s=1.0, aquecimento_s=0.0, imprimir=False):
              gr.basic_block.__init__(
                  self,
                  name="Monitor BLER",
                  in_sig=[np.uint8, np.uint8],
                  out_sig=[np.float32] * 2,
              )
              self.chave_tag = pmt.intern(tag_name)
              self.taxa_relogio = float(taxa_relogio)
              self.janela_s = float(janela_s)
              self.aquecimento_s = float(aquecimento_s)
              self.imprimir = bool(imprimir)
              self.em_aquecimento = self.aquecimento_s > 0

              # contadores acumulados desde o início (ou desde o fim do aquecimento)
              self.relogio = 0            # itens (bits) consumidos na porta 0
              self.quadros_recebidos = 0  # quadros que chegaram ao CRC (porta 0)
              self.quadros_validos = 0    # quadros que passaram no CRC (porta 1)

              # "foto" dos contadores no momento do último relatório, para
              # calcular só o que aconteceu na janela atual (por subtração)
              self.contadores_ultimo_relatorio = (0, 0)
              self.proximo_relatorio_em_s = self.janela_s

          def forecast(self, noutput_items, ninputs):
              # Não exige um mínimo de itens de entrada: o bloco só reporta
              # quando alguma das portas trouxer dados, e não fica em polling.
              return [0, 0]

          def general_work(self, input_items, output_items):
              itens_porta_0 = len(input_items[0])
              if itens_porta_0:
                  for tag in self.get_tags_in_window(
                          0, 0, itens_porta_0, self.chave_tag):
                      self.quadros_recebidos += 1
                  self.relogio += itens_porta_0
                  self.consume(0, itens_porta_0)

              itens_porta_1 = len(input_items[1])
              if itens_porta_1:
                  for tag in self.get_tags_in_window(
                          1, 0, itens_porta_1, self.chave_tag):
                      self.quadros_validos += 1
                  self.consume(1, itens_porta_1)

              tempo_sinal_s = self.relogio / self.taxa_relogio

              if self.em_aquecimento and tempo_sinal_s >= self.aquecimento_s:
                  self.em_aquecimento = False
                  self.relogio = 0
                  self.quadros_recebidos = 0
                  self.quadros_validos = 0
                  self.contadores_ultimo_relatorio = (0, 0)
                  self.proximo_relatorio_em_s = self.janela_s
                  if self.imprimir:
                      print(f"[aquecimento] {tempo_sinal_s:.2f}s de sinal "
                            f"descartados; contadores zerados", flush=True)
                  return 0

              pode_escrever_saida = len(output_items[0]) >= 1
              if tempo_sinal_s >= self.proximo_relatorio_em_s and pode_escrever_saida:
                  self.proximo_relatorio_em_s = (
                      tempo_sinal_s // self.janela_s + 1) * self.janela_s
                  for indice_saida, valor in enumerate(self.montar_relatorio()):
                      output_items[indice_saida][0] = valor
                  return 1
              return 0

          def calcular_bler(self, quadros_recebidos, quadros_validos):
              if not quadros_recebidos:
                  return float("nan")
              return 1.0 - quadros_validos / quadros_recebidos

          def montar_relatorio(self):
              (quadros_recebidos_anterior, quadros_validos_anterior) = (
                  self.contadores_ultimo_relatorio)

              bler_janela = self.calcular_bler(
                  self.quadros_recebidos - quadros_recebidos_anterior,
                  self.quadros_validos - quadros_validos_anterior,
              )
              bler_total = self.calcular_bler(
                  self.quadros_recebidos, self.quadros_validos)

              if self.imprimir:
                  print(
                      f"[janela] recebidos={self.quadros_recebidos - quadros_recebidos_anterior:7d} "
                      f"válidos={self.quadros_validos - quadros_validos_anterior:7d}  "
                      f"BLER={bler_janela:.3e}",
                      flush=True,
                  )
                  print(
                      f"[total ] recebidos={self.quadros_recebidos:7d} "
                      f"válidos={self.quadros_validos:7d}  "
                      f"BLER={bler_total:.3e}",
                      flush=True,
                  )

              self.contadores_ultimo_relatorio = (
                  self.quadros_recebidos, self.quadros_validos)
              return [bler_janela, bler_total]
    aquecimento_s: aquecimento_segundos
    imprimir: 'False'
    janela_s: att_segundos
    tag_name: tag_name
    taxa_relogio: bit_rate
  states: {state: disabled}
- name: fec_extended_tagged_decoder_0
  id: fec_extended_tagged_decoder
  parameters:
    decoder_list: PC_dec
    lentagname: '"quadro"'
    mtu: '1500'
    puncpat: '''11'''
  states: {}
- name: fec_extended_tagged_encoder_0
  id: fec_extended_tagged_encoder
  parameters:
    encoder_list: PC_enc
    lentagname: '"quadro"'
    mtu: '1500'
    puncpat: '''11'''
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: Filtro de TX
    interp: sps
    taps: taps
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_1
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: taps/sps
    type: ccc
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    gui_hint: tabs@2:0,1,1,1
    samp_per_symbol: sps
    size: 100*sps
    srate: samp_rate
    type: complex
    ymax: '3.0'
    ymin: '-3.0'
  states: {}
- name: qtgui_number_sink_taxas
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    color3: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tabs@3
    label1: '"BLER (janela)"'
    label2: '"BLER (total)"'
    label3: '"BER (janela)"'
    label4: '"BER (total)"'
    min: '0'
    name: '"Taxa de erro de bloco"'
    nconnections: '4'
    type: float
    unit1: '""'
    unit2: '""'
    unit3: '""'
    unit4: '""'
  states: {}
- name: qtgui_number_sink_vazao_0
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    color3: ("blue", "red")
    factor1: '1e-3'
    factor2: '1e-3'
    factor3: '1e-3'
    factor4: '1e-3'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tabs@3
    label1: '"vazão (janela)"'
    label2: '"vazão (total)"'
    label3: '"goodput (janela)"'
    label4: '"goodput (total)"'
    max: bit_rate/1e3
    min: '0'
    name: '"Vazão (barra = fração da taxa de bits no canal)"'
    nconnections: '4'
    type: float
    unit1: '"kb/s"'
    unit2: '"kb/s"'
    unit3: '"kb/s"'
    unit4: '"kb/s"'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@0:1,0,1,1
    name: '"teste"'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@1:1,1,1,1
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: baud_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@2:1,0,1,2
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@0:0,0,1,1
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"quadro"'
    type: float
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@2:0,0,1,1
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '2.0'
    ymin: '-2.0'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@2:0,2,1,1
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '10.0'
    ymin: '-10.0'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 3,0,20,1
    label0: Transmissor
    label1: Canal
    label2: Receptor
    label3: Métricas
    num_tabs: '4'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_signal
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx_signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx_signal
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rx_signal
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_random_uniform_source_x_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_char_to_float_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_file_source_0_0, '0', blocks_unpack_k_bits_bb_0_1, '0']
- [blocks_multiply_const_vxx_0, '0', digital_costas_loop_cc_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_pack_k_bits_bb_1, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_stream_mux_0, '0', blocks_char_to_float_0, '0']
- [blocks_stream_mux_0, '0', blocks_throttle2_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', digital_crc32_bb_0_0_0, '0']
- [blocks_throttle2_0, '0', blocks_pack_k_bits_bb_1, '0']
- [blocks_throttle2_0_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_throttle2_0_0, '0', epy_block_1, '2']
- [blocks_unpack_k_bits_bb_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_stream_mux_0, '0']
- [blocks_unpack_k_bits_bb_0_1, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [channels_channel_model_0, '0', qtgui_sink_x_0_0, '0']
- [channels_channel_model_0, '0', virtual_sink_1, '0']
- [digital_constellation_encoder_bc_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_constellation_soft_decoder_cf_0, '0', epy_block_0_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_soft_decoder_cf_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_sink_x_1, '0']
- [digital_crc32_bb_0, '0', epy_block_1, '1']
- [digital_crc32_bb_0_0, '0', fec_extended_tagged_encoder_0, '0']
- [digital_crc32_bb_0_0_0, '0', blocks_throttle2_0_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [epy_block_0_0, '0', fec_extended_tagged_decoder_0, '0']
- [epy_block_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [epy_block_1, '0', qtgui_number_sink_taxas, '0']
- [epy_block_1, '1', qtgui_number_sink_taxas, '1']
- [epy_block_1, '2', qtgui_number_sink_taxas, '2']
- [epy_block_1, '3', qtgui_number_sink_taxas, '3']
- [epy_block_1, '4', qtgui_number_sink_vazao_0, '0']
- [epy_block_1, '5', qtgui_number_sink_vazao_0, '1']
- [epy_block_1, '6', qtgui_number_sink_vazao_0, '2']
- [epy_block_1, '7', qtgui_number_sink_vazao_0, '3']
- [fec_extended_tagged_decoder_0, '0', blocks_char_to_float_0_0_0, '0']
- [fec_extended_tagged_decoder_0, '0', digital_crc32_bb_0, '0']
- [fec_extended_tagged_decoder_0, '0', epy_block_1, '0']
- [fec_extended_tagged_encoder_0, '0', blocks_stream_mux_0, '1']
- [interp_fir_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', virtual_sink_0, '0']
- [interp_fir_filter_xxx_1, '0', analog_agc_xx_0, '0']
- [interp_fir_filter_xxx_1, '0', qtgui_eye_sink_x_0, '0']
- [interp_fir_filter_xxx_1, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0, '0', channels_channel_model_0, '0']
- [virtual_source_1, '0', interp_fir_filter_xxx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
